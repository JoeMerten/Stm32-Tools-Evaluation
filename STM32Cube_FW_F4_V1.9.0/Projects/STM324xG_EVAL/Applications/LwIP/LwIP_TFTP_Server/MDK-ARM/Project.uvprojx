# Keil uVision project Project.uvprojx, settings and files
target STM324xG_EVAL (ARM-ADS)
  device: STM32F407IGHx STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM324xG_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_STM324xG_EVAL
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM324xG_EVAL;..\..\..\..\..\..\Drivers\BSP\Components;..\..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include;..\..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include\lwip                                   ;..\..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include\netif;..\..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include\ipv4;..\..\..\..\..\..\Middlewares\Third_Party\LwIP\system;..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src;..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src\Drivers;..\..\..\..\..\..\Utilities;..\..\..\..\..\..\Utilities\Log
  asm include: ROJ_DIR$\..\inc
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/LwIP/Core
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/: tcp_in.c def.c lwip_timers.c memp.c dhcp.c udp.c mem.c stats.c netif.c tcp.c tcp_out.c raw.c sys.c init.c dns.c pbuf.c
  group Middlewares/LwIP/Core/IPv4
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: igmp.c inet.c ip_addr.c inet_chksum.c ip_frag.c autoip.c ip.c icmp.c
  group Middlewares/LwIP/Api
    ../../../../../../Middlewares/Third_Party/LwIP/src/api/: api_msg.c netbuf.c tcpip.c api_lib.c sockets.c err.c netdb.c netifapi.c
  group Drivers/BSP/STM324xG_EVAL
    ../../../../../../Drivers/BSP/STM324xG_EVAL/: stm324xg_eval.c stm324xg_eval_sram.c stm324xg_eval_io.c stm324xg_eval_sd.c stm324xg_eval_lcd.c
  group Middlewares/FatFs/Drivers
    ../../../../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Middlewares/LwIP/Netif
    ../../../../../../Middlewares/Third_Party/LwIP/src/netif/: etharp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash.c stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_sram.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_uart.c stm32f4xx_hal_i2c.c stm32f4xx_hal_sd.c stm32f4xx_hal_eth.c stm32f4xx_hal_dma.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: ethernetif.c main.c stm32f4xx_it.c app_ethernet.c tftputils.c tftpserver.c
  group Doc
    ../: readme.txt
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c ff.c diskio.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ili9325/: ili9325.c
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
  group Application/Utilities
    ../../../../../../Utilities/Log/: lcd_log.c
software components: CMSIS:CORE 4.1.0
