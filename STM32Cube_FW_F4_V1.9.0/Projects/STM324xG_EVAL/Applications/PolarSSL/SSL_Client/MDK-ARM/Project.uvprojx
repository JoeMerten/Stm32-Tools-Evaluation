# Keil uVision project Project.uvprojx, settings and files
target STM3241G_EVAL (ARM-ADS)
  device: STM32F417IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.6
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM3241G_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F417xx,USE_STM324xG_EVAL
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM324xG_EVAL;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\BSP\Components;..\..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include\;..\..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include\ipv4;..\..\..\..\..\..\Middlewares\Third_Party\LwIP\system;..\..\..\..\..\..\Middlewares\Third_Party\LwIP\system\OS;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\..\..\..\..\Middlewares\Third_Party\polarssl\include;..\..\..\..\..\..\Utilities;..\..\..\..\..\..\Utilities\Fonts
  asm include: ROJ_DIR$\..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Middlewares/LwIP/Netif
    ../../../../../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
    ../../../../../../Middlewares/Third_Party/LwIP/src/netif/: etharp.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: timers.c tasks.c queue.c list.c croutine.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middlewares/LwIP/Api
    ../../../../../../Middlewares/Third_Party/LwIP/src/api/: api_msg.c netbuf.c netifapi.c err.c tcpip.c sockets.c api_lib.c netdb.c
  group Application/User
    ../Src/: main.c app_ethernet.c ssl_client.c stm32f4xx_it.c stm32f4xx_hal_msp.c ethernetif.c
    ./: retarget.c
  group Application/MDK-ARM
    ./: startup_stm32f417xx.s
  group Middlewares/LwIP/Core
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/: stats.c raw.c lwip_timers.c tcp.c dns.c sys.c tcp_out.c memp.c dhcp.c def.c init.c mem.c tcp_in.c udp.c netif.c pbuf.c
  group Middlewares/LwIP/Core/IPv4
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: icmp.c inet.c ip_frag.c inet_chksum.c autoip.c igmp.c ip_addr.c ip.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
    ../../../../../../Drivers/BSP/Components/ili9325/: ili9325.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM324xG_EVAL
    ../../../../../../Drivers/BSP/STM324xG_EVAL/: stm324xg_eval_lcd.c stm324xg_eval_sram.c stm324xg_eval_io.c stm324xg_eval.c
  group Middlewares/PolarSSL
    ../../../../../../Middlewares/Third_Party/PolarSSL/library/: xtea.c asn1write.c sha2.c ctr_drbg.c debug.c dhm.c padlock.c entropy.c sha4.c ssl_srv.c entropy_poll.c certs.c sha1.c pbkdf2.c x509parse.c camellia.c havege.c pkcs11.c timing.c version.c ssl_tls.c blowfish.c cipher_wrap.c pkcs5.c arc4.c bignum.c md.c md_wrap.c md4.c rsa.c pem.c error.c des.c pkcs12.c md2.c cipher.c md5.c base64.c x509write.c gcm.c aes.c net.c ssl_cache.c ssl_cli.c asn1parse.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_hash.c stm32f4xx_hal_cortex.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_uart.c stm32f4xx_hal.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rng.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_sram.c stm32f4xx_hal_gpio.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_cryp.c stm32f4xx_hal_rcc_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
software components: CMSIS:CORE 4.1.0
