# Keil uVision project Project.uvprojx, settings and files
target STM324xG-EVAL_USBH-FS (ARM-ADS)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.6
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM324xG-EVAL_USBH-FS
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_STM324xG_EVAL,USE_USB_FS
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Class\CDC\Inc;..\..\..\..\..\..\Drivers\BSP\STM324xG_EVAL;..\..\..\..\..\..\Utilities\Log;..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src;..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Utilities
    ../../../../../../Utilities/Log/: lcd_log.c
  group Drivers/BSP/STM324xG_EVAL
    ../../../../../../Drivers/BSP/STM324xG_EVAL/: stm324xg_eval_sd.c stm324xg_eval_lcd.c stm324xg_eval.c stm324xg_eval_io.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_pipes.c usbh_ioreq.c usbh_ctlreq.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Application/User
    ../Src/: stm32f4xx_it.c usbh_conf.c cdc_receive.c explorer.c cdc_configuration.c cdc_send.c main.c menu.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
    ../../../../../../Drivers/BSP/Components/ili9325/: ili9325.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c diskio.c ff.c
  group Middlewares/STM32_USBH_Library/Class/CDC
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/CDC/Src/: usbh_cdc.c
  group Middlewares/FatFs/Drivers
    ../../../../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_hcd.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_i2c_ex.c stm32f4xx_ll_fsmc.c stm32f4xx_hal.c stm32f4xx_ll_usb.c stm32f4xx_hal_sram.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma.c stm32f4xx_hal_sd.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_gpio.c
target STM324xG-EVAL_USBH-HS (ARM-ADS)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.6
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM324xG-EVAL_USBH-HS
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_STM324xG_EVAL,USE_USB_HS
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 4.1.0
