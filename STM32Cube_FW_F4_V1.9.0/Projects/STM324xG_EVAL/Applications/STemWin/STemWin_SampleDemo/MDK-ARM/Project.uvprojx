# Keil uVision project Project.uvprojx, settings and files
target STM324xG_EVAL (ARM-ADS)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.6
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM324xG_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F417xx,USE_STM324xG_EVAL
  c misc: --C99
  c include: ..\Inc;..\Demo;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\inc;..\..\..\..\..\..\Drivers\BSP\STM324xG_EVAL;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\BSP\Components;..\..\..\..\..\..\Middlewares\ST\STemWin\inc;..\..\..\..\..\..\Utilities;..\..\..\..\..\..\Utilities\Fonts
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Middlewares/STemWin/Config
    ../Src/: LCDConf_stm3240g_eval.c GUIConf_stm3240g_eval.c
    ../../../../../../Middlewares/ST/STemWin/OS/: GUI_X.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/STemWin/Lib
    ../../../../../../Middlewares/ST/STemWin/Lib/: STemWin528_CM4_Keil.lib
  group Drivers/BSP/STM324xG_EVAL
    ../../../../../../Drivers/BSP/STM324xG_EVAL/: stm324xg_eval_ts.c stm324xg_eval.c stm324xg_eval_io.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_flash.c stm32f4xx_hal.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_i2c.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_crc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_sram.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_tim.c stm32f4xx_hal_dma.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: stm32f4xx_it.c rtc.c calibration.c main.c
  group Application/Demo
    ../Demo/: GUIDEMO_ColorBar.c GUIDEMO.c GUIDEMO_Listview.c GUIDEMO_BarGraph.c GUIDEMO_RadialMenu.c GUIDEMO_WashingMachine.c GUIDEMO_Skinning.c GUIDEMO_TransparentDialog.c GUIDEMO_Start.c GUIDEMO_Speed.c GUIDEMO_Resource.c GUIDEMO_Speedometer.c GUIDEMO_Conf.c GUIDEMO_IconView.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_Graph.c GUIDEMO_Intro.c GUIDEMO_ImageFlow.c GUIDEMO_Cursor.c GUIDEMO_Automotive.c GUIDEMO_AntialiasedText.c GUIDEMO_ZoomAndRotate.c GUIDEMO_Bitmap.c GUIDEMO_Fading.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
    ../../../../../../Drivers/BSP/Components/ili9325/: ili9325.c
software components: CMSIS:CORE 4.1.0
