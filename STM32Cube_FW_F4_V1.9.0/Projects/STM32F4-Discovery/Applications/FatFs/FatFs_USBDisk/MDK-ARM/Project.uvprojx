# Keil uVision project Project.uvprojx, settings and files
target STM32F4-DISCO (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.6
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F4-DISCO
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_STM32F4_DISCO
  c misc: --C99
  c include: ..\inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32F4-Discovery;..\..\..\..\..\..\Middlewares\ST\STM32_USB_HOST_Library\Core\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_USB_HOST_Library\Class\MSC\Inc;..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src;..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: ff.c diskio.c ff_gen_drv.c
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_HOST_Library/Class/MSC/Src/: usbh_msc_scsi.c usbh_msc_bot.c usbh_msc.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32F4_DISCO
    ../../../../../../Drivers/BSP/STM32F4-Discovery/: stm32f4_discovery.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_HOST_Library/Core/Src/: usbh_pipes.c usbh_core.c usbh_ctlreq.c usbh_ioreq.c
  group Drivers/STM32F4xx_HAL_Drivers
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pwr.c stm32f4xx_hal_i2c.c stm32f4xx_hal_hcd.c stm32f4xx_hal.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_ll_usb.c stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c
  group Middlewares/FatFs/Drivers
    ../../../../../../Middlewares/Third_Party/FatFs/src/drivers/: usbh_diskio.c
  group Application/User
    ../Src/: stm32f4xx_it.c main.c usbh_conf.c
software components: CMSIS:CORE 4.1.0
