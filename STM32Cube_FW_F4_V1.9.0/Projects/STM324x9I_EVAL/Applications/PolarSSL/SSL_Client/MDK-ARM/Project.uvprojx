# Keil uVision project Project.uvprojx, settings and files
target STM324x9I_EVAL (ARM-ADS)
  device: STM32F439NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.6
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM324x9I_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F439xx,USE_STM324x9I_EVAL
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM324x9I_EVAL;..\..\..\..\..\..\Drivers\BSP\Components;..\..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include\;..\..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include\ipv4;..\..\..\..\..\..\Middlewares\Third_Party\LwIP\system;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\..\..\..\..\Middlewares\Third_Party\polarssl\include;..\..\..\..\..\..\Utilities;..\..\..\..\..\..\Utilities\Fonts
  asm include: ROJ_DIR$\..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c croutine.c timers.c
  group Drivers/BSP/STM324x9I_EVAL
    ../../../../../../Drivers/BSP/STM324x9I_EVAL/: stm324x9i_eval_io.c stm324x9i_eval_lcd.c stm324x9i_eval_sdram.c stm324x9i_eval.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middlewares/LwIP/Netif
    ../../../../../../Middlewares/Third_Party/LwIP/src/netif/: etharp.c
    ../../../../../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Middlewares/LwIP/Core
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/: tcp_out.c dhcp.c netif.c mem.c tcp_in.c memp.c raw.c def.c stats.c pbuf.c tcp.c sys.c dns.c init.c udp.c lwip_timers.c
  group Application/User
    ../Src/: app_ethernet.c stm32f4xx_hal_msp.c ssl_client.c stm32f4xx_it.c main.c ethernetif.c
    ./: retarget.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/LwIP/Core/IPv4
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: inet.c igmp.c icmp.c inet_chksum.c ip.c autoip.c ip_addr.c ip_frag.c
  group Application/MDK-ARM
    ./: startup_stm32f439xx.s
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/stmpe1600/: stmpe1600.c
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_cortex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rng.c stm32f4xx_hal_i2c.c stm32f4xx_hal_hash.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal.c stm32f4xx_hal_uart.c stm32f4xx_hal_pwr.c stm32f4xx_hal_gpio.c stm32f4xx_hal_eth.c stm32f4xx_ll_fmc.c stm32f4xx_hal_flash.c stm32f4xx_hal_cryp.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_i2c_ex.c
  group Middlewares/PolarSSL
    ../../../../../../Middlewares/Third_Party/PolarSSL/library/: aes.c md4.c asn1write.c timing.c sha1.c havege.c gcm.c debug.c arc4.c net.c md2.c dhm.c x509parse.c bignum.c error.c ssl_cli.c cipher.c padlock.c des.c version.c x509write.c ssl_cache.c md_wrap.c pkcs11.c ssl_tls.c base64.c blowfish.c pem.c sha2.c pkcs5.c asn1parse.c md5.c ctr_drbg.c entropy_poll.c pbkdf2.c camellia.c sha4.c cipher_wrap.c ssl_srv.c md.c pkcs12.c rsa.c xtea.c entropy.c certs.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Doc
    ../: readme.txt
  group Middlewares/LwIP/Api
    ../../../../../../Middlewares/Third_Party/LwIP/src/api/: netifapi.c sockets.c api_lib.c netbuf.c api_msg.c tcpip.c err.c netdb.c
software components: CMSIS:CORE 4.1.0
