# Keil uVision project Project.uvprojx, settings and files
target STM324x9I-EVAL_USBH-FS (ARM-ADS)
  device: STM32F429NIHx STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM324x9I-EVAL_USBH-FS
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_STM324x9I_EVAL,USE_USB_FS
  c misc: --C99
  c include: ..\inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM324x9I_EVAL;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Middlewares\ST\STM32_USB_HOST_Library\Core\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_USB_HOST_Library\Class\MSC\Inc;..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src;..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt readme.txt readme.txt
  group Drivers/BSP/STM324x9I_EVAL
    ../../../../../../Drivers/BSP/STM324x9I_EVAL/: stm324x9i_eval.c stm324x9i_eval_io.c stm324x9i_eval.c stm324x9i_eval_io.c stm324x9i_eval.c stm324x9i_eval_io.c
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_HOST_Library/Class/MSC/Src/: usbh_msc_scsi.c usbh_msc_bot.c usbh_msc.c usbh_msc_scsi.c usbh_msc_bot.c usbh_msc.c usbh_msc_scsi.c usbh_msc_bot.c usbh_msc.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c diskio.c ff.c ff_gen_drv.c diskio.c ff.c ff_gen_drv.c diskio.c ff.c
  group Drivers/STM32F4xx_HAL_Drivers
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_hcd.c stm32f4xx_hal_pwr.c stm32f4xx_ll_usb.c stm32f4xx_hal_i2c_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_sdram.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_crc.c stm32f4xx_hal_i2s.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_ll_fmc.c stm32f4xx_hal.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_sram.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_pwr.c stm32f4xx_ll_usb.c stm32f4xx_hal_i2c_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_sdram.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_crc.c stm32f4xx_hal_i2s.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_ll_fmc.c stm32f4xx_hal.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_sram.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_pwr.c stm32f4xx_ll_usb.c stm32f4xx_hal_i2c_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_sdram.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_crc.c stm32f4xx_hal_i2s.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_ll_fmc.c stm32f4xx_hal.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_sram.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash_ex.c
  group Application/User
    ../Src/: main.c usbh_conf.c stm32f4xx_it.c main.c usbh_conf.c stm32f4xx_it.c main.c usbh_conf.c stm32f4xx_it.c
  group Middlewares/FatFs/Drivers
    ../../../../../../Middlewares/Third_Party/FatFs/src/drivers/: usbh_diskio.c usbh_diskio.c usbh_diskio.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c system_stm32f4xx.c system_stm32f4xx.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_HOST_Library/Core/Src/: usbh_pipes.c usbh_ioreq.c usbh_ctlreq.c usbh_pipes.c usbh_ioreq.c usbh_ctlreq.c usbh_pipes.c usbh_ioreq.c usbh_ctlreq.c
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_core.c usbh_core.c
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s startup_stm32f429xx.s startup_stm32f429xx.s
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/stmpe1600/: stmpe1600.c stmpe1600.c stmpe1600.c
target STM324x9I-EVAL_USBH-HS (ARM-ADS)
  device: STM32F429NIHx STMicroelectronics
  cpu: as above
  output: STM324x9I-EVAL_USBH-HS
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_STM324x9I_EVAL,USE_USB_HS
  c misc: --C99
  c include: as above
  library: MicroLIB
  link misc: --diag_suppress=L6329
target STM324x9I-EVAL_USBH-HS-IN-FS (ARM-ADS)
  device: STM32F429NIHx STMicroelectronics
  cpu: as above
  output: STM324x9I-EVAL_USBH-HS-IN-FS
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_STM324x9I_EVAL,USE_USB_HS,USE_USB_HS_IN_FS
  c misc: --C99
  c include: as above
  library: MicroLIB
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 4.1.0
