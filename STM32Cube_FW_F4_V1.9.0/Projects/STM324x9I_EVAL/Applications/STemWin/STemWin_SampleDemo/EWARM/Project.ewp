# IAR project Project.ewp, settings and files
configuration STM324x9I_EVAL_MB1046 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429NI ST STM32F429NI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F429xx; USE_STM324x9I_EVAL; USE_MB1046
  ICCARM.CCIncludePath2: ..\Inc; ..\Demo; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM324x9I_EVAL; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\BSP\Components; ..\..\..\..\..\..\Middlewares\ST\STemWin\inc; ..\..\..\..\..\..\Utilities; ..\..\..\..\..\..\Utilities\Fonts
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f429xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM324x9I_EVAL_MB1063 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F429xx; USE_STM324x9I_EVAL; USE_MB1063
  group Application/Demo
    ../Demo/: GUIDEMO.c GUIDEMO.h GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
  group Application/EWARM
    ./: startup_stm32f429xx.s
  group Application/User
    ../Src/: calibration.c main.c rtc.c stm32f4xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/exc7200/: exc7200.c
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
    ../../../../../../Drivers/BSP/Components/ts3510/: ts3510.c
  group Drivers/BSP/STM324x9I_EVAL
    ../../../../../../Drivers/BSP/STM324x9I_EVAL/: stm324x9i_eval.c stm324x9i_eval_sdram.c stm324x9i_eval_ts.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_fmc.c
  group Middlewares/STemWin/Config
    ../../../../../../Middlewares/ST/STemWin/OS/: GUI_X.c
    ../Src/: GUIConf.c LCDConf_stm324x9i_eval_MB1046.c LCDConf_stm324x9i_eval_MB1063.c
  group Middlewares/STemWin/inc
    ../../../../../../Middlewares/ST/STemWin/inc/: BUTTON.h BUTTON_Private.h CALENDAR.h CHECKBOX.h CHECKBOX_Private.h CHOOSECOLOR.h CHOOSEFILE.h DIALOG.h DIALOG_Intern.h DROPDOWN.h DROPDOWN_Private.h EDIT.h EDIT_Private.h FRAMEWIN.h FRAMEWIN_Private.h Global.h GRAPH.h GRAPH_Private.h GUI.h GUI_ARRAY.h GUI_ARRAY_Private.h GUI_BMP_Private.h GUI_ConfDefaults.h GUI_Debug.h GUI_FontIntern.h GUI_GIF_Private.h GUI_HOOK.h GUI_JPEG_Private.h GUI_Private.h GUI_SetOrientation.h GUI_SetOrientationCX.h GUI_SPRITE_Private.h GUI_Type.h GUI_Version.h GUI_VNC.h GUIDRV_DCache.h GUIDRV_DCache_Private.h GUIDRV_Dist.h GUIDRV_FlexColor.h GUIDRV_FlexColor_Private.h GUIDRV_Generic.h GUIDRV_Lin.h GUIDRV_Lin_Opt_16.h GUIDRV_Lin_Opt_24.h GUIDRV_Lin_Opt_32.h GUIDRV_Lin_Opt_8.h GUIDRV_Lin_Private.h GUIDRV_NoOpt_1_8.h GUIDRV_Template.h GUIDRV_TemplateI.h GUIDRV_TemplateI_Private.h HEADER.h HEADER_Private.h ICONVIEW.h ICONVIEW_Private.h IMAGE.h IMAGE_Private.h LCD.h LCD_ConfDefaults.h LCD_Private.h LCD_Protected.h LCD_SIM.h LISTBOX.h LISTBOX_Private.h LISTVIEW.h LISTVIEW_Private.h LISTWHEEL.h LISTWHEEL_Private.h MENU.h MENU_Private.h MESSAGEBOX.h MULTIEDIT.h MULTIPAGE.h MULTIPAGE_Private.h PROGBAR.h PROGBAR_Private.h RADIO.h RADIO_Private.h SCROLLBAR.h SCROLLBAR_Private.h SLIDER.h SLIDER_Private.h SPINBOX.h SPINBOX_Private.h TEXT.h TEXT_Private.h TREEVIEW.h TREEVIEW_Private.h WIDGET.h WINDOW_Private.h WM.h WM_GUI.h WM_Intern.h
  group Middlewares/STemWin/Lib
    ../../../../../../Middlewares/ST/STemWin/Lib/: STemWin528_CM4_IAR.a
