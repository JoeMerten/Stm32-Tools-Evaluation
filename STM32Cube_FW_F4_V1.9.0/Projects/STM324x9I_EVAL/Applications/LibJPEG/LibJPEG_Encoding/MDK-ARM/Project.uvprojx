# Keil uVision project Project.uvprojx, settings and files
target STM324x9I_EVAL (ARM-ADS)
  device: STM32F429NIHx STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM324x9I_EVAL
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_STM324x9I_EVAL
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM324x9I_EVAL;..\..\..\..\..\..\Middlewares\Third_Party\LibJPEG\include;..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src;..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src\Drivers
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group Drivers/BSP/STM324x9I_EVAL
    ../../../../../../Drivers/BSP/STM324x9I_EVAL/: stm324x9i_eval_io.c stm324x9i_eval_sd.c stm324x9i_eval_lcd.c stm324x9i_eval_sdram.c stm324x9i_eval.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: ff.c diskio.c ff_gen_drv.c
  group Application/User
    ../Src/: stm32f4xx_it.c main.c decode.c encode.c
  group Middlewares/FatFs/Drivers
    ../../../../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Middlewares/Lib_JPEG
    ../../../../../../Middlewares/Third_Party/LibJPEG/source/: jcmarker.c jcapistd.c jcarith.c jdapimin.c jdcoefct.c jcomapi.c jaricom.c jcinit.c jddctmgr.c jdinput.c jcmainct.c jdarith.c jcsample.c jdatadst.c jidctfst.c jccolor.c jdsample.c jcapimin.c jccoefct.c jidctflt.c jcprepct.c jdpostct.c jmemnobs.c jidctint.c jdmarker.c jdtrans.c jdhuff.c jfdctint.c jctrans.c jdmaster.c jdatasrc.c jchuff.c jcmaster.c jquant1.c jcparam.c jquant2.c jdmerge.c jmemmgr.c jdcolor.c jdmainct.c jcdctmgr.c jerror.c jfdctfst.c jutils.c jdapistd.c jfdctflt.c
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/stmpe1600/: stmpe1600.c
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_sram.c stm32f4xx_hal_pcd.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pccard.c stm32f4xx_hal_sdram.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rng.c stm32f4xx_hal_i2c.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_nor.c stm32f4xx_hal_hash.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_crc.c stm32f4xx_hal_rtc.c stm32f4xx_hal.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_adc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_gpio.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_irda.c stm32f4xx_ll_fmc.c stm32f4xx_hal_flash.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_tim.c stm32f4xx_hal_can.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_i2s.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_usart.c stm32f4xx_hal_spi.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_hcd.c stm32f4xx_hal_nand.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_sd.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 4.1.0
