# Keil uVision project Project.uvprojx, settings and files
target STM32469I_EVAL (ARM-ADS)
  device: STM32F469NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.6
  cpu: IRAM(0x20000000-0x2004FFFF) IRAM2(0x10000000-0x2000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32469I_EVAL
  c flags: Optim=4 wLevel=2
  c define: USE_HAL_DRIVER,STM32F469xx,USE_IOEXPANDER
  c misc: --C99
  c include: ..\Inc;..\Demo;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32469I_EVAL;..\..\..\..\..\..\Drivers\BSP\Components\mfxstm32l152;..\..\..\..\..\..\Drivers\BSP\Components\ili9325;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\BSP\Components;..\..\..\..\..\..\Middlewares\ST\STemWin\inc;..\..\..\..\..\..\Utilities;..\..\..\..\..\..\Utilities\Fonts
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c
    ../../../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c
  group Application/MDK-ARM
    ./: startup_stm32f469xx.s
  group Middlewares/STemWin/Lib
    ../../../../../../Middlewares/ST/STemWin/Lib/: STemWin528_CM4_Keil.lib
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rtc.c stm32f4xx_hal_gpio.c stm32f4xx_ll_fmc.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_tim.c stm32f4xx_hal_flash.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_sram.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal.c stm32f4xx_hal_sdram.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma_ex.c
  group Application/Demo
    ../Demo/: GUIDEMO_Graph.c GUIDEMO_ImageFlow.c GUIDEMO_Speedometer.c GUIDEMO_VScreen.c GUIDEMO_TransparentDialog.c GUIDEMO_Intro.c GUIDEMO_WashingMachine.c GUIDEMO_Conf.c GUIDEMO_Speed.c GUIDEMO_Treeview.c GUIDEMO_BarGraph.c GUIDEMO_RadialMenu.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Listview.c GUIDEMO_Resource.c GUIDEMO_ZoomAndRotate.c GUIDEMO.c GUIDEMO_Automotive.c GUIDEMO_Start.c GUIDEMO_AntialiasedText.c GUIDEMO_Skinning.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_IconView.c
  group Middlewares/STemWin/Config
    ../../../../../../Middlewares/ST/STemWin/OS/: GUI_X.c
    ../Src/: LCDConf_stm32469i_eval.c GUIConf_stm32469i_eval.c
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/BSP/STM32469I_EVAL
    ../../../../../../Drivers/BSP/STM32469I_EVAL/: stm32469i_eval_sdram.c stm32469i_eval.c stm32469i_eval_ts.c stm32469i_eval_io.c
  group Application/User
    ../Src/: calibration.c stm32f4xx_it.c rtc.c main.c
software components: CMSIS:CORE 4.1.0
