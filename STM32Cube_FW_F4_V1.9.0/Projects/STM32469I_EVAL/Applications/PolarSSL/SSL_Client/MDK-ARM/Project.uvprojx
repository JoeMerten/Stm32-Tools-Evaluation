# Keil uVision project Project.uvprojx, settings and files
target STM32479I_EVAL (ARM-ADS)
  device: STM32F479NI STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.6
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x50000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32479I_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F479xx,USE_STM32469I_EVAL,USE_IOEXPANDER
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32469I_EVAL;..\..\..\..\..\..\Drivers\BSP\Components;..\..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include\;..\..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include\ipv4;..\..\..\..\..\..\Middlewares\Third_Party\LwIP\system;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\..\..\..\..\Middlewares\Third_Party\polarssl\include;..\..\..\..\..\..\Utilities\Log;..\..\..\..\..\..\Utilities\Fonts
  asm include: ROJ_DIR$\..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f479xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_gpio.c stm32f4xx_ll_fmc.c stm32f4xx_hal_flash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_dsi.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal.c stm32f4xx_hal_sdram.c stm32f4xx_hal_hash.c stm32f4xx_hal_rcc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_cryp.c stm32f4xx_hal_rng.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_eth.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c tasks.c queue.c list.c timers.c
  group Middlewares/LwIP/Api
    ../../../../../../Middlewares/Third_Party/LwIP/src/api/: err.c api_msg.c netbuf.c tcpip.c netdb.c sockets.c api_lib.c netifapi.c
  group Doc
    ../: readme.txt
  group Middlewares/LwIP/Core
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/: pbuf.c def.c udp.c tcp.c memp.c dns.c mem.c tcp_in.c tcp_out.c dhcp.c lwip_timers.c raw.c stats.c init.c sys.c netif.c
  group Middlewares/LwIP/Netif
    ../../../../../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
    ../../../../../../Middlewares/Third_Party/LwIP/src/netif/: etharp.c
  group Middlewares/PolarSSL
    ../../../../../../Middlewares/Third_Party/PolarSSL/library/: sha2.c asn1parse.c ssl_tls.c md.c md_wrap.c base64.c pkcs5.c blowfish.c cipher_wrap.c pkcs12.c cipher.c ssl_srv.c pkcs11.c x509write.c camellia.c x509parse.c bignum.c md5.c net.c md2.c gcm.c havege.c aes.c entropy.c debug.c md4.c sha1.c ssl_cache.c pem.c rsa.c xtea.c dhm.c version.c des.c ssl_cli.c padlock.c ctr_drbg.c certs.c asn1write.c entropy_poll.c sha4.c timing.c error.c pbkdf2.c arc4.c
  group Drivers/BSP/STM32469I_EVAL
    ../../../../../../Drivers/BSP/STM32469I_EVAL/: stm32469i_eval_io.c stm32469i_eval_lcd.c stm32469i_eval.c stm32469i_eval_sdram.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/LwIP/Core/IPv4
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: ip.c inet_chksum.c autoip.c ip_addr.c ip_frag.c inet.c igmp.c icmp.c
  group Application/User
    ../Src/: stm32f4xx_it.c ssl_client.c app_ethernet.c stm32f4xx_hal_msp.c ethernetif.c main.c
    ./: retarget.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
software components: CMSIS:CORE 4.1.0
