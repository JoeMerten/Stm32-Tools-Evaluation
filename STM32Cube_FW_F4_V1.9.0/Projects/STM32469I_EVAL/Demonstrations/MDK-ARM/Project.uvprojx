# Keil uVision project Project.uvprojx, settings and files
target STM32469I-Eval_Demo (ARM-ADS)
  device: STM32F469NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.6
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x50000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32469I-Eval_Demo +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F469xx,USE_HAL_DRIVER,USE_STM32469I_EVAL,USE_USB_HS,USE_IOEXPANDER
  c misc: --C99
  c include: ..\inc;..\STemWin_Addons;..\Config;..\Core\inc;..\Modules\vncserver;..\..\..\..\Utilities\CPU;..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\Drivers\BSP\STM32469I_EVAL;..\..\..\..\Drivers\BSP\Components;..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\Middlewares\Third_Party\LwIP\src\include\;..\..\..\..\Middlewares\Third_Party\LwIP\src\include\ipv4                                                              ;..\..\..\..\Middlewares\Third_Party\LwIP\system;..\..\..\..\Middlewares\Third_Party\LwIP\system\OS;..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc;..\..\..\..\Middlewares\ST\STemWin\inc;..\..\..\..\Middlewares\Third_Party\FatFs\src;..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers;..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\Modules\audio_player\Addons\SpiritDSP_Equalizer;..\Modules\audio_player\Addons\SpiritDSP_LoudnessControl
  asm include: ROJ_DIR$\..\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: STM32469I-Eval_Demo\STM32469I-Eval_Demo.sct
  link misc: --diag_suppress=L6329
  group Application/User/Modules/Common
    ../Modules/Common/: audio_if.c
  group Application/User/Modules/gardening_control
    ../Modules/gardening_control/: gardening_control_win.c
  group Middlewares/LwIP/Core
    ../../../../Middlewares/Third_Party/LwIP/src/core/: tcp.c raw.c mem.c udp.c memp.c dns.c tcp_out.c pbuf.c stats.c sys.c dhcp.c lwip_timers.c init.c netif.c def.c tcp_in.c
  group Middlewares/USBH_Library/Config
    ../Config/: usbh_conf.c
  group Middlewares/FatFs/Core
    ../../../../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c diskio.c ff.c
  group Application/User/Modules/sys_info
    ../Modules/settings/: settings_win.c
  group Application/User/Modules/Audio
    ../Modules/audio_player/: audio_player_app.c audio_player_win.c
  group Application/User/Modules/Audio/Addons
    ../Modules/audio_player/Addons/SpiritDSP_Equalizer/: lib_equalizer_cortex_m4.a
    ../Modules/audio_player/Addons/SpiritDSP_LoudnessControl/: lib_loudness_cortex_m4.a
  group Middlewares/PDM
    ../../../../Middlewares/ST/STM32_Audio/Addons/PDM/: libPDMFilter_CM4_Keil.lib
  group Application/User/Modules/games
    ../Modules/games/: games_win.c
  group Middlewares/STemWin/ST_GUI_Addons
    ../STemWin_Addons/: STM32469I_EVAL_STemWin_Addons_Keil.lib
  group Middlewares/FreeRTOS
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/: tasks.c list.c croutine.c queue.c event_groups.c timers.c
  group Middlewares/FreeRTOS/Portable
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/LwIP/Api
    ../../../../Middlewares/Third_Party/LwIP/src/api/: api_lib.c sockets.c err.c tcpip.c netifapi.c netdb.c netbuf.c api_msg.c
  group Middlewares/LwIP/Core/IPv4
    ../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: igmp.c ip.c icmp.c inet.c ip_addr.c ip_frag.c inet_chksum.c autoip.c
  group Middlewares/FatFs/Drivers
    ../../../../Middlewares/Third_Party/FatFs/src/drivers/: usbh_diskio.c
  group Middlewares/LwIP/Netif
    ../../../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
    ../../../../Middlewares/Third_Party/LwIP/src/netif/: etharp.c
  group Application/User/Modules/VideoPlayer
    ../Modules/videoplayer/: video_player_win.c
  group Drivers/STM32F4_HAL_Driver
    ../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dsi.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_hash.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal_msp_template.c stm32f4xx_hal_nand.c stm32f4xx_hal_crc.c stm32f4xx_hal_can.c stm32f4xx_hal_pccard.c stm32f4xx_hal.c stm32f4xx_hal_cryp_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c stm32f4xx_hal_nor.c stm32f4xx_hal_qspi.c stm32f4xx_hal_adc.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_eth.c stm32f4xx_hal_hcd.c stm32f4xx_hal_dac.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_i2s.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_flash.c stm32f4xx_hal_fmpi2c.c stm32f4xx_ll_fmc.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sdram.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_uart.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_sram.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cec.c stm32f4xx_hal_cryp.c stm32f4xx_hal_dma.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_tim.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_sai.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_smartcard.c
  group Middlewares/FatFs/Options
    ../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Drivers/BSP/Component
    ../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c
    ../../../../Drivers/BSP/Components/wm8994/: wm8994.c
    ../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c
    ../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
  group Application/User/Modules/vnc_server
    ../Modules/vnc_server/: vnc_server_win.c vnc_app.c ethernetif.c
  group Application/User/Utilities
    ../../../../Utilities/CPU/: cpu_utils.c
  group Drivers/BSP/STM32469I_EVAL
    ../../../../Drivers/BSP/STM32469I_EVAL/: stm32469i_eval.c stm32469i_eval_audio.c stm32469i_eval_ts.c stm32469i_eval_io.c stm32469i_eval_qspi.c stm32469i_eval_sdram.c
  group Middlewares/USBH_Library/Core
    ../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_ioreq.c usbh_ctlreq.c usbh_pipes.c usbh_core.c
  group Application/User/Modules/home_alarm
    ../Modules/home_alarme/: home_alarm_win.c
  group Application/User/Modules/audio_recorder
    ../Modules/audio_recorder/: audio_recorder_win.c audio_recorder_app.c
  group Middlewares/USBH_Library/Class/MSC
    ../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc_bot.c usbh_msc_scsi.c usbh_msc.c
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_it.c k_module.c k_rtc.c k_storage.c k_bsp.c k_startup.c k_menu.c
  group Application/MDK-ARM
    ./: startup_stm32f469xx.s
  group Middlewares/STemWin/Library
    ../../../../Middlewares/ST/STemWin/Lib/: STemWin528_CM4_OS_Keil_ot.lib
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/STemWin/Config
    ../Config/: GUIConf.c LCDConf.c
  group Middlewares/STemWin/OS
    ../../../../Middlewares/ST/STemWin/OS/: GUI_X_OS.c
    ../Config/: GUI_X_FreeRTOS.c
software components: CMSIS:CORE 4.1.0
