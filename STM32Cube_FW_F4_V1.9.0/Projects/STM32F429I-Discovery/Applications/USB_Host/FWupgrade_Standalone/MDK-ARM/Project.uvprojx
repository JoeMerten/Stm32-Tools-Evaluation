# Keil uVision project Project.uvprojx, settings and files
target STM32F429I-DISCO (ARM-ADS)
  device: STM32F429ZITx STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F429I-DISCO
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_STM32F429I_DISCO
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32F429I-Discovery;..\..\..\..\..\..\Middlewares\ST\STM32_USB_HOST_Library\Core\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_USB_HOST_Library\Class\MSC\Inc;..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src;..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group Drivers/STM32F4xx_HAL_Drivers
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_spi.c stm32f4xx_hal_flash_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_HOST_Library/Core/Src/: usbh_ioreq.c usbh_ctlreq.c
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_pipes.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ili9341/: ili9341.c
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
  group Drivers/BSP/STM32F429I_DISCO
    ../../../../../../Drivers/BSP/STM32F429I-Discovery/: stm32f429i_discovery.c
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_HOST_Library/Class/MSC/Src/: usbh_msc_bot.c usbh_msc_scsi.c
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c
  group Application/User
    ../Src/: command.c usbh_diskio.c iap_menu.c flash_if.c main.c usbh_conf.c stm32f4xx_it.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Middlewares/FatFs
    ../../../../../../Middlewares/Third_Party/FatFs/src/: ff.c
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 4.1.0
