# Keil uVision project Project.uvprojx, settings and files
target STM32F429I_DISCO (ARM-ADS)
  device: STM32F429NIHx STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F429I_DISCO
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_STM32F429I_DISCO,USE_USB_OTG_HS,USE_EMBEDDED_PHY
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32F429I-Discovery;..\..\..\..\..\..\Middlewares\Third_Party\LibJPEG\include;..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src;..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src\Drivers;..\..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\inc
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group Drivers/BSP/STM32F429I_DISCO
    ../../../../../../Drivers/BSP/STM32F429I-Discovery/: stm32f429i_discovery.c stm32f429i_discovery_lcd.c stm32f429i_discovery_io.c stm32f429i_discovery_sdram.c
  group Application/User
    ../Src/: main.c decode.c encode.c stm32f4xx_it.c usbh_conf.c
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc_scsi.c usbh_msc.c usbh_msc_bot.c
  group Middlewares/Lib_JPEG
    ../../../../../../Middlewares/Third_Party/LibJPEG/source/: jccoefct.c jdarith.c jdatasrc.c jdatadst.c jchuff.c jdpostct.c jidctflt.c jcmainct.c jdmaster.c jdinput.c jdsample.c jquant1.c jdcolor.c jcomapi.c jcprepct.c jccolor.c jdmarker.c jcmarker.c jmemmgr.c jcsample.c jidctfst.c jcinit.c jcparam.c jctrans.c jdapimin.c jfdctint.c jddctmgr.c jmemnobs.c jdmainct.c jcmaster.c jdtrans.c jfdctflt.c jquant2.c jaricom.c jidctint.c jutils.c jdcoefct.c jcarith.c jerror.c jcdctmgr.c jdapistd.c jcapistd.c jcapimin.c jdmerge.c jfdctfst.c jdhuff.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_ctlreq.c usbh_core.c usbh_pipes.c usbh_ioreq.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dac.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_can.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_rng.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_flash.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_gpio.c stm32f4xx_ll_fmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_sram.c stm32f4xx_hal_spi.c stm32f4xx_ll_usb.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_uart.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_dma.c stm32f4xx_hal_nand.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_sdram.c stm32f4xx_hal_pccard.c stm32f4xx_hal_adc.c stm32f4xx_hal_irda.c stm32f4xx_hal_cryp.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_nor.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_tim.c stm32f4xx_hal_hash.c stm32f4xx_hal_pcd.c stm32f4xx_hal.c stm32f4xx_hal_rcc.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_pwr.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_sai.c stm32f4xx_hal_usart.c stm32f4xx_ll_fsmc.c
  group Middlewares/FatFs/Drivers
    ../../../../../../Middlewares/Third_Party/FatFs/src/drivers/: usbh_diskio.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/stmpe1600/: stmpe1600.c
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
    ../../../../../../Drivers/BSP/Components/ili9341/: ili9341.c
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 4.1.0
