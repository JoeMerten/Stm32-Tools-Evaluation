# Keil uVision project Project.uvprojx, settings and files
target STM32F429I-Discovery (ARM-ADS)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.6
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F429I-Discovery
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F439xx,USE_STM32F429I_DISCO,USE_USB_HS
  c misc: --C99
  c include: ..\Core\inc;..\Config;..\..\..\..\Utilities\CPU;..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\Drivers\BSP\STM32F429I-Discovery;..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\..\..\..\Middlewares\ST\STemWin\inc;..\..\..\..\Middlewares\Third_Party\FatFs\src;..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers;..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\..\..\..\Middlewares\Third_Party\LwIP\src\include\;..\..\..\..\Middlewares\Third_Party\LwIP\src\include\ipv4                                                              ;..\..\..\..\Middlewares\Third_Party\LwIP\system
  asm include: ROJ_DIR$\..\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Middlewares/STemWin/Config
    ../Config/: GUIConf.c LCDConf.c LCDConf_stm32f429i_disco_MB1075.c
  group Middlewares/STM32_USBH_Library/Config
    ../Config/: usbh_conf.c
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User/Core
    ../Core/Src/: main.c k_module.c k_calibration.c stm32f4xx_it.c k_modules_res.c k_bsp.c k_mem.c k_rtc.c k_storage.c k_menu.c k_startup.c k_log.c
  group Application/User/Modules/Benchmark
    ../Modules/benchmark/: benchmark_win.c
  group Drivers/BSP/Components
    ../../../../Drivers/BSP/Components/ili9341/: ili9341.c
    ../../../../Drivers/BSP/Components/ts3510/: ts3510.c
    ../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
  group Application/User/Modules/Game
    ../Modules/game/: game_win.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_usart.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_irda.c stm32f4xx_hal_flash.c stm32f4xx_hal_sdram.c stm32f4xx_hal_cortex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sd.c stm32f4xx_hal_can.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_spi.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_hash.c stm32f4xx_hal_hcd.c stm32f4xx_hal_dma.c stm32f4xx_hal_crc.c stm32f4xx_hal_nor.c stm32f4xx_hal_uart.c stm32f4xx_hal_sram.c stm32f4xx_hal.c stm32f4xx_hal_rng.c stm32f4xx_hal_i2s.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_cryp.c stm32f4xx_ll_usb.c stm32f4xx_hal_flash_ex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_nand.c stm32f4xx_hal_adc.c stm32f4xx_hal_gpio.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_pwr.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_tim.c stm32f4xx_hal_pccard.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_rcc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_sai_ex.c
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc_scsi.c usbh_msc_bot.c usbh_msc.c
  group Application/User/Modules/ImageBrowser
    ../Modules/imagebrowser/: imagebrowser_win.c
  group Application/User/Modules/System
    ../Modules/system/: system_win.c
  group Drivers/BSP/STM32F429I_Discovery
    ../../../../Drivers/BSP/STM32F429I-Discovery/: stm32f429i_discovery.c stm32f429i_discovery_lcd.c stm32f429i_discovery_ts.c stm32f429i_discovery_sdram.c stm32f429i_discovery_io.c
  group Middlewares/FreeRTOS
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/: tasks.c croutine.c list.c queue.c timers.c
  group Middlewares/FreeRTOS/Portable
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Drivers/CMSIS
    ../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Middlewares/FatFs/Drivers
    ../../../../Middlewares/Third_Party/FatFs/src/drivers/: usbh_diskio.c
  group Middlewares/STemWin/Library
    ../../../../Middlewares/ST/STemWin/Lib/: STemWin528_CM4_OS_Keil.lib
  group Middlewares/FatFs/Options
    ../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Application/User/Utilities
    ../../../../Utilities/CPU/: cpu_utils.c
  group Middlewares/STemWin/OS
    ../../../../Middlewares/ST/STemWin/OS/: GUI_X_OS.c
  group Application/User/Modules/FileBrowser
    ../Modules/filebrowser/: filebrowser_app.c filebrowser_win.c
  group Application/User/Modules/VideoPlayer
    ../Modules/videoplayer/: videoplayer_win.c
  group Doc
    ../: readme.txt
  group Middlewares/STM32_USBH_Library/Core
    ../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_pipes.c usbh_ioreq.c usbh_ctlreq.c usbh_core.c
  group Middlewares/FatFs/Core
    ../../../../Middlewares/Third_Party/FatFs/src/: ff.c ff_gen_drv.c diskio.c
software components: CMSIS:CORE 4.1.0
