# Keil uVision project Project.uvprojx, settings and files
target STM32F401-Discovery (ARM-ADS)
  device: STM32F401VCTx STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x08000000-0x0803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F401-Discovery
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xC,USE_STM32F401_DISCO
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\inc;..\..\..\..\..\..\Drivers\BSP\STM32F401-Discovery
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group Example/MDK-ARM
    ./: startup_stm32f401xc.s
  group Doc
    ../: readme.txt
  group Example/User
    ../Src/: stm32f4xx_it.c stm32f4xx_lp_modes.c stm32f4xx_hal_msp.c main.c
  group Drivers/BSP/STM32F401-Discovery
    ../../../../../../Drivers/BSP/STM32F401-Discovery/: stm32f401_discovery.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_flash.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_rtc.c stm32f4xx_hal_spi.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_gpio.c
software components: CMSIS:CORE 4.1.0
